## hardware/firmware/main/Kconfig.projbuild
```kconfig
menu "Zhiya diagnostics"

config ZHIYA_H07_AUDIO_DIAGNOSTIC
    bool "Use the H07 audio diagnostic screen"
    default n

endmenu
```
